# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=9
  c include: ..\FWLib\include;..\SYSTEM\init;..\SYSTEM\delay;..\SYSTEM\uart;..\USER;..\HARDWARE\led;..\HARDWARE\18b20;..\HARDWARE\max31856
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/18b20/: 18b20.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/max31856/: max31856.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/init/: init.c
    ../SYSTEM/uart/: uart.c
  group FWLib
    ../FWLib/source/: stc_gpio.c stc_uart.c
